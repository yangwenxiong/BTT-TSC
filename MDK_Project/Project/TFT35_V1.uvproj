# Keil uVision project TFT35_V1.uvproj, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  AfterMake: ..\axf2bin.bat BIGTREE_TFT35_V3.0.20
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,SOFTWARE_VERSION=20, TFT35_V1_2
  c include: ..\..\firmware\TFT35\src\Libraries\cmsis;..\..\firmware\TFT35\src\Libraries\fwlib\inc;..\..\firmware\TFT35\src\Libraries\fwlib;..\..\firmware\TFT35\src\User;..\..\firmware\TFT35\src\User\Hal;..\..\firmware\TFT35\src\User\Menu;..\..\firmware\TFT35\src\User\Fatfs;..\..\firmware\TFT35\src\User\API;..\..\firmware\TFT35\src\User\API\Language;..\..\firmware\TFT35\src\User\API\UI;..\..\firmware\TFT35\src\User\API\Gcode;..\..\firmware\TFT35\src\User\API\Vfs;..\..\firmware\TFT35\src\User\STM32_USB_HOST_Library\Core\inc;..\..\firmware\TFT35\src\User\STM32_USB_HOST_Library\Class\MSC\inc;..\..\firmware\TFT35\src\User\STM32_USB_HOST_Library\Usr\inc;..\..\firmware\TFT35\src\User\STM32_USB_OTG_Driver\inc;..\..\firmware\TFT35\src\User\STM32_USB_HOST_Library
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x2a000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../: startup_stm32f10x_cl.s
  group Cortex-M3
    ../../firmware/TFT35/src/Libraries/cmsis/: core_cm3.c system_stm32f10x.c stm32f10x.h
  group StdLib
    ../../firmware/TFT35/src/Libraries/fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Hal
    ../../firmware/TFT35/src/User/Hal/: lcd.c sd.c spi.c sw_spi.c usart.c w25qxx.c xpt2046.c spi_slave.c Serial.c
  group USB_FS_HOST/Core
    ../../firmware/TFT35/src/User/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_FS_HOS/Class
    ../../firmware/TFT35/src/User/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_FS_HOS/Usr
    ../../firmware/TFT35/src/User/STM32_USB_HOST_Library/Usr/src/: usb_bsp.c usbh_usr.c
  group USB_OTG
    ../../firmware/TFT35/src/User/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group Fatfs
    ../../firmware/TFT35/src/User/Fatfs/: cc936.c ff.c myfatfs.c diskio.c
  group Api
    ../../firmware/TFT35/src/User/API/: coordinate.c flashStore.c interfaceCmd.c parseACK.c boot.c LCD_Encoder.c
  group Api/VFS
    ../../firmware/TFT35/src/User/API/Vfs/: vfs.c
  group Api/Gcode
    ../../firmware/TFT35/src/User/API/Gcode/: gcode.c mygcodefs.c
  group Api/Language
    ../../firmware/TFT35/src/User/API/Language/: Language.c Language.h language_cn.h language_en.h language_ru.h language_jp.h language_am.h language_de.h
  group Api/UI
    ../../firmware/TFT35/src/User/API/UI/: GUI.c touch_process.c ui_draw.c ST7920_Simulator.c
  group Menu
    ../../firmware/TFT35/src/User/Menu/: BabyStep.c Extrude.c Fan.c Heat.c Home.c MainPage.c menu.c Move.c Popup.c PowerFailed.c Print.c Printing.c Speed.c Settings.c Mode.c
  group User
    ../../firmware/TFT35/src/User/: delay.c my_misc.c os_timer.c includes.h main.c Configuration.h variants.h
